# Keil uVision project Baseboard V1.0.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Baseboard V1.0 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Driver\CMSIS;..\Output;..\Project;..\Driver\Libraries\inc;..\Driver\Libraries\src;..\Driver\Libraries\Startup;..\Driver\Startup;..\Driver\CMSIS\CM3\CoreSupport;..\Driver\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver\CMSIS\Documentation;..\USER;..\MYLIB\MOTOR;..\SYSTEM\timer;..\MYLIB\PID;..\MYLIB\ECODE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32F10X
    ../Driver/Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../Driver/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Driver/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Driver/Startup/: startup_stm32f10x_md.s
  group USER
    ../USER/: main.c
  group MYLIB
    ../MYLIB/MOTOR/: motor.c
    ../MYLIB/PID/: pid.c
    ../MYLIB/ECODE/: ecode.c
  group SYSTEM
    ../SYSTEM/timer/: timer.c
software components: CMSIS:CORE 5.0.0
